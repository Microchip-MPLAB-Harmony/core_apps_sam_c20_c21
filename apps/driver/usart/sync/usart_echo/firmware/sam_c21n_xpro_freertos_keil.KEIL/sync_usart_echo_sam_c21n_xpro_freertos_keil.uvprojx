# Keil uVision project sync_usart_echo_sam_c21n_xpro_freertos_keil.uvprojx, settings and files
target sam_c21n_xpro_freertos_keil (6140000::V6.14::ARMCLANG)
  device: ATSAMC21N18A Microchip
  pack: Keil.SAM-C_DFP.1.4.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sam_c21n_xpro_freertos_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_c21n_xpro_freertos_keil;..\src\packs\ATSAMC21N18A_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS;..\src\third_party\rtos\FreeRTOS\Source\include;.;..\src\third_party\rtos\FreeRTOS\Source\portable\KEIL\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\src\config\sam_c21n_xpro_freertos_keil\sam_c21n_xpro_freertos_keil.sct
  group Harmony3
    ../src/config/sam_c21n_xpro_freertos_keil/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/sam_c21n_xpro_freertos_keil/peripheral/evsys/: plib_evsys.h plib_evsys.c
    ../src/config/sam_c21n_xpro_freertos_keil/driver/usart/: drv_usart_definitions.h drv_usart.h
    ../src/config/sam_c21n_xpro_freertos_keil/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h FreeRTOSConfig.h user.h configuration.h initialization.c interrupts.c exceptions.c startup_keil.c freertos_hooks.c tasks.c
    ../src/packs/ATSAMC21N18A_DFP/component/: ac.h adc.h can.h ccl.h dac.h divas.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h hmatrixb.h mclk.h mtb.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pm.h port.h ptc.h rstc.h rtc.h sdadc.h sercom.h supc.h tc.h tcc.h tsens.h wdt.h
    ../src/packs/ATSAMC21N18A_DFP/instance/: ac.h adc0.h adc1.h can0.h can1.h ccl.h dac.h divas.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h hmatrixhs.h mclk.h mtb.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pm.h port.h ptc.h rstc.h rtc.h sdadc.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tsens.h wdt.h
    ../src/packs/ATSAMC21N18A_DFP/: samc21n18a.h
    ../src/packs/ATSAMC21N18A_DFP/pio/: samc21n18a.h
    ../src/config/sam_c21n_xpro_freertos_keil/peripheral/port/: plib_port.h plib_port.c
    ../src/config/sam_c21n_xpro_freertos_keil/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/sam_c21n_xpro_freertos_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/config/sam_c21n_xpro_freertos_keil/peripheral/sercom/usart/: plib_sercom4_usart.h plib_sercom_usart_common.h plib_sercom4_usart.c
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm0plus.h mpu_armv7.h cachel1_armv7.h
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/KEIL/ARM_CM0/: portmacro.h port.c
    ../src/config/sam_c21n_xpro_freertos_keil/driver/: driver.h driver_common.h
    ../src/config/sam_c21n_xpro_freertos_keil/system/: system.h system_common.h system_module.h
    ../src/config/sam_c21n_xpro_freertos_keil/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_c21n_xpro_freertos_keil/system/dma/: sys_dma.h sys_dma_mapping.h sys_dma.c
    ../src/config/sam_c21n_xpro_freertos_keil/osal/: osal.h osal_definitions.h osal_freertos.h osal_freertos.c
    ../src/: app_usart_echo.h main.c app_usart_echo.c
    ../src/config/sam_c21n_xpro_freertos_keil/system/debug/: sys_debug.h
    ../src/config/sam_c21n_xpro_freertos_keil/bsp/: bsp.h bsp.c
    ../src/config/sam_c21n_xpro_freertos_keil/driver/usart/src/: drv_usart.c drv_usart_local.h
    ../src/config/sam_c21n_xpro_freertos_keil/stdio/: keil_monitor.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_c21n_xpro_freertos_keil/system/int/src/: sys_int.c
